# Repository youngd24/BurbSec_GenCoin

File README.md:

# BurbSec_GenCoin
Generic BurbSec Meetup challenge coin, not specific to one.

## KiCad design BurbSec_GenCoin.kicad_pcb

Board: 2 copper layers, 50.0 x 50.0 mm, 21 parts (1 on the bottom side), 18 nets.

Parts:
BT1: BK-5067; BAT_BK-5067
C1: 10uF; C_0805_2012Metric
C2, C3: 10nF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: LED; LED_0603_1608Metric
R1, R2: 10k; R_0603_1608Metric
R3, R4: 680R; R_0603_1608Metric
U1: NE555DR; SOIC-8_W3.9mm
U2: 74HC4017D_653; SO16_SOT109-1_NEX

Connections:
GND: BT1.-, C1.2, C2.2, C3.2, R3.2, R4.1, U1.1 (GND), U2.8 (GND), U2.13 (*CP1), U2.15 (MR)
unnamed: D1.2 (A), U1.3 (OUT), U2.14 (CP0)
unnamed: D1.1 (K), R3.1
unnamed: D2.2 (A), U2.11 (Q9)
unnamed: D3.2 (A), U2.9 (Q8)
unnamed: D4.2 (A), U2.6 (Q7)
unnamed: D5.2 (A), U2.5 (Q6)
unnamed: D6.2 (A), U2.1 (Q5)
unnamed: D7.2 (A), U2.10 (Q4)
unnamed: D8.2 (A), U2.7 (Q3)
unnamed: D9.2 (A), U2.4 (Q2)
unnamed: D10.2 (A), U2.2 (Q1)
unnamed: D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), R4.2
unnamed: D11.2 (A), U2.3 (Q0)
unnamed: C2.1, U1.5 (CONT)
unnamed: R1.2, R2.1, U1.7 (DISCH)
unnamed: C1.1, R2.2, U1.2 (TRIG), U1.6 (THRES)
VCC: BT1.S+1, C3.1, R1.1, U1.4 (RST), U1.8 (VCC), U2.16 (VCC)

## Commit log

2024-12-30 Initial version
2024-12-30 added burbsec logo assets
2024-12-30 added discord join link file
2025-01-06 updated to add gerbers and bom
2025-01-06 minor update to bom
2025-01-06 changed QR to new one and type
2025-01-06 updated jpg assets for new qr code
